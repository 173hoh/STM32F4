# Keil uVision project RC522.uvprojx, settings and files
target USART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED_096 +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=5
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\DHT11;..\HARDWARE\SPI;..\HARDWARE\RC522;..\HARDWARE\dht11;..\HARDWARE\ws2812B;..\HARDWARE\Control;..\HARDWARE\Init;..\HARDWARE\ADC;..\HARDWARE\oled
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/SPI/: spi_driver.c
    ../HARDWARE/RC522/: RC522.c
    ../HARDWARE/dht11/: dht11.c dht11.h
    ../HARDWARE/ws2812B/: ws2812B.c ws2812B.h
    ../HARDWARE/Control/: control.c control.h
    ../HARDWARE/Init/: Allinit.c Allinit.h
    ../HARDWARE/ADC/: ADC.c ADC.h
    ../HARDWARE/oled/: OLED.c OLED.h OLED_Font.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c
  group README
    ../: README.TXT
