# Keil uVision project TEMPLATE.uvprojx, settings and files
target TEMPLATE (::::)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMPLATE +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Core\Inc;..\Core\Src;..\Core;..\HW\Application\Display;..\HW\Application\Key;..\HW\Application\PID;..\HW\Application\Task;..\HW\Common;..\HW\Driver\DS18B20;..\HW\Driver\TM1638;..\USER;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\HW\Hardware\Port;..\HW\Hardware\Timer;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\HW\Application\Onenet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/Src/: gpio.c iwdg.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c system_stm32f1xx.c
    ../Core/Inc/: stm32f1xx_hal_conf.h
  group User
    ../USER/: main.c
  group HW
    ../HW/Application/Display/: Display.c
    ../HW/Application/Key/: Key.c
    ../HW/Application/PID/: PID.c
    ../HW/Application/Task/: Task.c
    ../HW/Common/: Debug.c Debug.h Typedefine.h
    ../HW/Driver/DS18B20/: DS18B20.c
    ../HW/Driver/TM1638/: TM1638.c
    ../HW/Hardware/Port/: Port.c
    ../HW/Hardware/Timer/: Timer.c
    ../HW/Application/Onenet/: esp01s.c MQTT.c onenet.c
  group Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h
software components: Device:Startup 1.0.0
