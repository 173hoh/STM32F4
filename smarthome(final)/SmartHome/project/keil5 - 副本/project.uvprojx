# Keil uVision project project.uvprojx, settings and files
target SmartHome (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F427ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,GD32F427
  c include: ..\..\library\GD32F4xx_standard_peripheral\Include;..\..\library\CMSIS\GD\GD32F4xx\Include;..\..\library\CMSIS;..\..\board\inc;..\..\bsp\inc;..\..\module\inc;..\..\app\inc
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry Reset_Handler --first __Vectors
  group cmsis
    ../../library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../../library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group library
    ../../library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_adc.c gd32f4xx_gpio.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_timer.c gd32f4xx_dma.c
  group board
    ../../board/src/: board.c board_led.c board_uart.c gd32f4xx_it.c systick.c
  group bsp
    ../../bsp/src/: bsp_adc.c bsp_basic_timer.c bsp_led.c bsp_pwm.c bsp_usart.c
  group module
    ../../module/src/: beep.c bmp180.c dht11.c dwin.c esp8266.c flame.c fpm383.c hx1838.c ky037.c motor.c mq2.c rc522.c relay.c sr602.c step2p4w.c su03t.c tc1508.c temt6000.c ws2812.c
  group app
    ../../app/src/: main.c test.c
    ./: test_init.c test_init.h
